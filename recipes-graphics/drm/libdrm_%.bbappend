# Enable Tegra DRM support for kmssink and DRM testing utilities
PACKAGECONFIG:append:tegra = " tegra"
